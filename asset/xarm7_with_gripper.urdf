Commit message: update opendoor urdf, fix collect bugs

File: asset/xarm7_with_gripper.urdf (robot description, URDF)
Before this commit: robot xarm7_with_gripper, 24 links, 23 joints
Joints:
- joint mobile_rotation: type continuous -> fixed
- joint mobile_translation: type prismatic -> fixed
